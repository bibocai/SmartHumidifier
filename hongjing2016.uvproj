# Keil uVision project hongjing2016.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: hongjing2016 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group src
    ./src/: main.c delay.c infracsonic.c Uart.c dht11.c nokia5110.c
